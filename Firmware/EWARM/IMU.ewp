# IAR project IMU.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Utilities\STM32F3_Discovery; ..\usb
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F3_Discovery_Demo_V1.1.0.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group Application/User
    ../: main.c main.h routine.c routine.h sens.c sens.h stm32f30x_conf.h stm32f30x_it.c stm32f30x_it.h system_stm32f30x.c
  group doc
    ../: readme.txt
  group STM32F3-Discovery
    ../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c stm32f3_discovery.h stm32f3_discovery_l3gd20.c stm32f3_discovery_l3gd20.h stm32f3_discovery_lsm303dlhc.c stm32f3_discovery_lsm303dlhc.h
  group STM32F30x_StdPeriph_Driver
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group USB/USB-FS-driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB/USB-user
    ../usb/: usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h USB_platform_config.c USB_platform_config.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
